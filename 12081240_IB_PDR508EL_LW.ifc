Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-03-28T15:16:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 28 15:16:33 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\78c4541b-220f-4cd3-ae41-a403ec320f93\8faf17d1-2a0a-4e9c-9ca1-5ab28a15c03d\ifc * Database version: 5507 * Database creation date: Mon Mar 28 15:16:32 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 28 15:16:33 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 28 15:16:33 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12081240_IB_PDR508EL_LW:52508352_IB_12081240_PDR508EL_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 52508352_IB_12081240_PDR508EL_LW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 52508352_IB_12081240_PDR508EL_LW
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Powder Coat_Grey, z_Miele_Design_Orange, z_Miele_Design_Glass, z_Miele_Design_Powder Coat_Lotus White, Polypropylene, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, Default
Pset_BuildingElementProxyCommon - sets with these values: 2
